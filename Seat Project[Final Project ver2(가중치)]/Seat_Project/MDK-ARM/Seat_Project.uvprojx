# Keil uVision project Seat_Project.uvprojx, settings and files
target Seat_Project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Seat_Project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c main.c stm32f1xx_it.c I2C_MPR121.c RTC_Android.c Timer.c
    ./: Uart.c Battery_Check.c Save_Power.c Indicator.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Document
    ./: ReadMe.txt
software components: CMSIS:CORE 4.1.0
